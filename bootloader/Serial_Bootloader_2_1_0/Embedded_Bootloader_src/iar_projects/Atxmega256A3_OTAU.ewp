# IAR project Atxmega256A3_OTAU.ewp, settings and files
configuration Bootloader_Atxmega256A3 (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: ATXMEGA256A3; EXT_MEMORY
  ICCAVR.CCDiagSuppress: Pa050, Pe188
  ICCAVR.newCCIncludePaths: ../application/common/include; ..; ../application/xmega/include; ../../../../Components/MAC_PHY/include; ../../../../Components/MAC_PHY/MAC_ENV/include; ../../../../Components/MAC_PHY/MAC_HWI/include; ../../../../Components/MAC_PHY/MAC_HWD_PHY/include
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICCAVR.PreInclude: configuration.h
  XLINK.XExtraOptions: -f ../linkerScr/avrxmega256a3.xcl
  group src
    ../application/xmega/src/: flashLoader.c spiSerializer.c eepromLoader.c uartSerializer.c hardwareInit.c sp_driver.s90
    ../application/xmega/include/: spiMemInterface.c
  group include
    ../application/xmega/include/: spiSerializer.h timerInterval.h sp_driver.h spiMemInterface.h uartSerializer.h hardwareInit.h eepromLoader.h
  group common/src
    ../application/common/src/: extMemReader.c memAt45db041.c abstractSerializer.c bootloader.c srecParser.c
  group common/include
    ../application/common/include/: abstractSerializer.h srecParser.h bootStructure.h types.h
  group configuration
    ../: configuration.h

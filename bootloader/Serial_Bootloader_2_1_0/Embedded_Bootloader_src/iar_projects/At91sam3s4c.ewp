# IAR project At91sam3s4c.ewp, settings and files
configuration Bootloader_At91sam3s4c (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  ICCARM.CCDefines: AT91SAM3S4C
  ICCARM.CCDiagSuppress: Pa050,Pe188
  ICCARM.PreInclude: configuration.h
  ICCARM.CCIncludePath2: ../application/common/include; ..; ../application/cortexm3/include; ../../../../Components/MAC_PHY/include; ../../../../Components/MAC_PHY/MAC_ENV/include; ../../../../Components/MAC_PHY/MAC_HWI/include; ../../../../Components/MAC_PHY/MAC_HWD_PHY/include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: AT91SAM3S4C
  OBJCOPY.OOCOutputFile: Bootloader.srec
  ILINK.IlinkOutputFile: Bootloader.out
  ILINK.IlinkIcfFile: ../linkerScr/at91SAM3S4C_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group src
    ../application/cortexm3/src/: flashLoader.c startup.c preparser.c enumeration.c descriptors.c dfuClass.c vectorTable.c eepromLoader.c usbSerializer.c hardwareInit.c
  group include
    ../application/cortexm3/include/: flashLoader.h descriptors.h timerInterval.h freqSelector.h AT91SAM3S4.h preparser.h dfuClass.h usbSerializer.h core_cm3.h usbShared.h hardwareInit.h eepromLoader.h
  group common/src
    ../application/common/src/: abstractSerializer.c bootloader.c srecParser.c
  group common/include
    ../application/common/include/: abstractSerializer.h srecParser.h bootStructure.h types.h
  group configuration
    ../: configuration.h

# IAR project Atmega128rfa1_OTAU.ewp, settings and files
configuration Bootloader_Atmega128rfa1 (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: ATMEGA128RFA1; EXT_MEMORY
  ICCAVR.CCDiagSuppress: Pa050, Pe188
  ICCAVR.newCCIncludePaths: ../application/common/include; ..; ../application/avr/include; ../../../../Components/MAC_PHY/include; ../../../../Components/MAC_PHY/MAC_ENV/include; ../../../../Components/MAC_PHY/MAC_HWI/include; ../../../../Components/MAC_PHY/MAC_HWD_PHY/include; ../../../../Components/MAC_PHY/MAC_HWD_PHY/ATMEGA128RFA1/PHY/include; ../../../../Components/MAC_PHY/MAC_HWD_PHY/ATMEGA128RFA1/MAC_HWD/include
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICCAVR.PreInclude: configuration.h
  XLINK.XExtraOptions: -f ../linkerScr/atmega128rfa1otau.xcl
  group src
    ../application/avr/src/: flashLoader.c eepromLoader.c uartSerializer.c calibMeasurement.s90 hardwareInit.c sp_driver.s90 usbFifoSerializer.c spiMemInterface.c
  group include
    ../application/avr/include/: spiMemInterface.h timerInterval.h sp_driver.h usbFifoSerializer.h uartSerializer.h hardwareInit.h eepromLoader.h
  group common/src
    ../application/common/src/: srecParser.c extMemReader.c memAt45db041.c abstractSerializer.c memAt25f2048.c bootloader.c
  group common/include
    ../application/common/include/: abstractSerializer.h srecParser.h bootStructure.h types.h
  group configuration
    ../: configuration.h
